FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://dimitrios_kernel_config.cfg"
